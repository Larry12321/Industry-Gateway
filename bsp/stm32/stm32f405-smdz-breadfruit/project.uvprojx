# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, USE_HAL_DRIVER, STM32F405xx, __STDC_LIMIT_MACROS
  c include: ..\..\..\components\drivers\include;packages\kawaii-mqtt-latest\common;packages\wiznet-latest\ioLibrary\Ethernet;..\..\..\libcpu\arm\common;.;..\..\..\components\net\sal\include;board;..\..\..\libcpu\arm\cortex-m4;packages\agile_modbus-v1.1.2\inc;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\config;packages\wiznet-latest\ioLibrary\Internet;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\finsh;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\socket;..\..\..\components\drivers\spi;packages\kawaii-mqtt-latest\platform\RT-Thread;..\..\..\components\net\at\include;..\..\..\include;..\..\..\components\net\sal\include\socket\sys_socket;packages\at_device-latest\class\sim76xx;packages\kawaii-mqtt-latest\network;..\..\..\components\drivers\include;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;applications;packages\kawaii-mqtt-latest\mqtt;..\libraries\HAL_Drivers;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\compilers\common\include;packages\kawaii-mqtt-latest\common\log;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\drivers\include;packages\kawaii-mqtt-latest\mqttclient;packages\cJSON-v1.7.17;..\..\..\components\utilities\ulog;board\CubeMX_Config\Inc;packages\agile_modbus-v1.1.2\util;..\..\..\components\net\sal\impl;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\net\at\at_socket;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\poll;..\libraries\HAL_Drivers\CMSIS\Include;packages\at_device-latest\inc;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group agile_modbus
    packages/agile_modbus-v1.1.2/src/: agile_modbus_tcp.c agile_modbus.c agile_modbus_rtu.c
    packages/agile_modbus-v1.1.2/util/: agile_modbus_slave_util.c
  group Applications
    applications/: main.c modbus_rtu_master.c init.c
  group AT
    ../../../components/net/at/at_socket/: at_socket.c
    ../../../components/net/at/src/: at_cli.c at_client.c at_utils.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/sim76xx/: at_device_sim76xx.c at_socket_sim76xx.c
    packages/at_device-latest/samples/: at_sample_sim76xx.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_parse.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/log/arch/rt-thread/: arch.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTDeserializePublish.c MQTTUnsubscribeClient.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTConnectServer.c MQTTUnsubscribeServer.c MQTTPacket.c MQTTFormat.c MQTTSubscribeServer.c MQTTConnectClient.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_thread.c platform_mutex.c platform_timer.c platform_net_socket.c
    packages/kawaii-mqtt-latest/common/: random.c mqtt_list.c
    packages/kawaii-mqtt-latest/test/: test_ca.c test.c
    packages/kawaii-mqtt-latest/common/log/: fifo.c format.c salof.c
    packages/kawaii-mqtt-latest/network/: nettype_tls.c nettype_tcp.c network.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cryp.c stm32f4xx_hal_qspi.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cec.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_rng.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c
    ../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
  group WIZnet
    packages/wiznet-latest/src/: wiz.c wiz_socket.c wiz_device.c wiz_ping.c wiz_af_inet.c
    packages/wiznet-latest/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_conf.c wizchip_socket.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
